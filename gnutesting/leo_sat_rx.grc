options:
  parameters:
    generate_options: qt_gui
    id: leo_sat_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate_tx
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}

connections:
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_tcp_source_0, '0', qtgui_time_sink_x_0, '0']
- [network_tcp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
